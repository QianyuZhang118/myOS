# Keil uVision project my_RTOS_GD32.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F407ZE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: my_RTOS_GD32
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./source/: app.c main.c switch.c tbitmap.c tCpu.c tEvent.c tFlagGroup.c tHooks.c tlist.c tMbox.c tMemBlock.c tMutex.c tSem.c tTask.c tTime.c tTimer.c myTask.h myTask.c
software components: CMSIS:CORE 5.5.0, Device:Libopt 3.0.2, Device:Startup 3.0.2, Device:StdPeripherals:EXTI 3.0.2, Device:StdPeripherals:GPIO 3.0.2, Device:StdPeripherals:MISC 3.0.2, Device:StdPeripherals:PMU 3.0.2, Device:StdPeripherals:RCU 3.0.2, Device:StdPeripherals:USART 3.0.2
